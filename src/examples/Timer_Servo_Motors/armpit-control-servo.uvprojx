# Keil uVision project armpit-control-servo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: armpit-adc-singleconversion
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_TIMER
  c include: ..\..\..\lib;.;..\..\..\util
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../../lib/: _components.h adc.cpp adc.h adc_cpp.h afio.cpp afio.h bkp.cpp bkp.h common.h dac.cpp dac.h dac_cpp.h dma.cpp dma.h dma_cpp.h exti.cpp exti.h gpio.cpp gpio.h gpio_cpp.h i2c.cpp i2c.h i2c_cpp.h pwr.cpp pwr.h rcc.h rcc_class.cpp rcc_cpp.h rtc.cpp rtc.h rtc_cpp.h spi.cpp spi.h spi_cpp.h system_init.cpp timer.cpp timer.h timer_cpp.h usart.cpp usart.h usart_cpp.h
    ../../../lib/core/: nvic.cpp nvic.h system_control.cpp system_control.h systick.cpp systick.h
    ../../../startup/: startup_stm32f10x_md.s
  group src
    ./: servo2.cpp
  group util
    ../../../util/button_handler/: button.cpp button.h button_handler.cpp button_handler.h
