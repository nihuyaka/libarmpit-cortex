# Keil uVision project _f4_keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armpit
  c flags: Optim=4 uC99=1 wLevel=2
  c define: USE_I2C USE_TIMER USE_USART
  c include: ..\..\..\lib;..\..\..\lib\stm32f4xx\lib;..\..\..\lib\util;..\..\..\lib\stm32_common;..\..\..\lib\mcortex_core\armv7m
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ../src/: chopper_balancer.cpp chopper_balancer.h chopper_esc.cpp chopper_esc.h irremote_proc.cpp irremote_proc.h main.cpp motionapp_reader.cpp motionapp_reader.h
    ../src/MPU6050/: helper_3dmath.h MPU6050.cpp MPU6050.h MPU6050_6Axis_MotionApps20.h
  group lib
    ../../../lib/stm32_common/: exti.cpp exti.h peripheral.cpp peripheral.h spi.cpp spi.h spi_cpp.h timer.cpp timer.h timer_cpp.h
    ../../../lib/stm32f4xx/lib/: dma.cpp dma.h dma_cpp.h flash.c flash.h gpio.cpp gpio.h gpio_cpp.h GPIO_Helper.cpp GPIO_Helper.h i2c.cpp i2c.h i2c_c.c i2c_cpp.h irq.h irq_f401xx.h irq_f405xx.h irq_f407xx.h irq_f411xx.h irq_f415xx.h irq_f417xx.h irq_f427xx.h irq_f429xx.h irq_f437xx.h irq_f439xx.h irq_f446xx.h new.h rcc.c rcc.h rcc_ahb.h rcc_apb1.h rcc_apb2.h rcc_bdcr.h rcc_cfgr.h rcc_ckgatenr.h rcc_cr.h rcc_csr.h RCC_Helper.c RCC_Helper.h rcc_pllcfgr.h system_init.c usart.cpp usart.h usart_cpp.h
    ../../../lib/stm32f4xx/startup/ARM/: startup_stm32f4xx.s
  group core
    ../../../lib/mcortex_core/: systick.c systick.h
    ../../../lib/mcortex_core/armv7m/: nvic.c nvic.h system_control.c system_control.h
  group util
    ../../../lib/util/: IRremote.cpp IRRemote.h
