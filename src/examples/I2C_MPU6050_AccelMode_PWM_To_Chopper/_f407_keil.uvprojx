# Keil uVision project _f407_keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armpit
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_I2C USE_TIMER
  c include: ..\..\lib;..\..\lib\stm32f4xx\lib;..\..\lib\util;..\..\lib\stm32_common;..\..\lib\mcortex_core\armv7m
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./: MPU6050.cpp MPU6050.h main.cpp
  group lib
    ../../lib/stm32f4xx/lib/: dma.cpp dma.h dma_cpp.h flash.c flash.h gpio.cpp gpio.h gpio_cpp.h i2c.cpp i2c.h i2c_cpp.h rcc.c rcc.h rcc_ahb.h rcc_apb1.h rcc_apb2.h rcc_bdcr.h rcc_cfgr.h rcc_ckgatenr.h rcc_cr.h rcc_csr.h rcc_pllcfgr.h system_init.c usart.cpp usart.h usart_cpp.h irq.h GPIO_Helper.cpp GPIO_Helper.h RCC_Helper.c RCC_Helper.h
    ../../lib/: _components.h common.h stm32.h
    ../../lib/stm32_common/: peripheral.cpp peripheral.h spi.cpp spi.h spi_cpp.h timer.cpp timer.h timer_cpp.h exti.cpp exti.h
    ../../lib/stm32f4xx/startup/ARM/: startup_stm32f4xx.s
  group core
    ../../lib/mcortex_core/armv7m/: nvic.c nvic.h system_control.c system_control.h
    ../../lib/mcortex_core/: systick.c systick.h
  group util
    ../../lib/util/: IRremote.cpp IRRemote.h
