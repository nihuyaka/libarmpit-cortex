# Keil uVision project keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L051K8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: keil
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group lib
    ../../lib/stm32l0x1/startup/arm/: startup_stm32l051xx.s
    ../../lib/common_stm32_m3_m4/: peripheral.cpp peripheral.h spi.cpp spi.h spi_cpp.h timer.cpp timer.h timer_cpp.h
    ../../lib/stm32l0x1/lib/core/: nvic.cpp nvic.h system_control.cpp system_control.h systick.cpp systick.h
  group src
    ./: main.cpp
